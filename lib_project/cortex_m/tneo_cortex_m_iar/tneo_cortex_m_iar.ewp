# IAR project tneo_cortex_m_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ../../../src; ../../../src/core; ../../../src/core/internal; ../../../src/arch
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../src; ../../../src/core
  ILINK.IlinkOutputFile: tneo_cortex_m_iar.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group arch
    ../../../src/arch/cortex_m/: tn_arch_cortex_m.S tn_arch_cortex_m_c.c
  group core
    ../../../src/core/: tn_dqueue.c tn_eventgrp.c tn_fmem.c tn_list.c tn_mutex.c tn_sem.c tn_sys.c tn_tasks.c tn_timer.c
