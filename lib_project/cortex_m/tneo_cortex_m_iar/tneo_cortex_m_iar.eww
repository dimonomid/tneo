<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\tneo_cortex_m_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>


