# Keil uVision project tneo_cortex_m_keil5.uvprojx, settings and files
target tneo_cortex_m_keil5 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tneo_cortex_m_keil5 (library)
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\src\core;..\..\..\src\core\internal;..\..\..\src;..\..\..\src\arch
  asm misc: --cpreproc
  asm include: ..\..\..\src;..\..\..\src\core
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group core
    ../../../src/core/: tn_timer.c tn_dqueue.c tn_eventgrp.c tn_fmem.c tn_list.c tn_mutex.c tn_sem.c tn_sys.c tn_tasks.c tn_timer_static.c tn_timer_dyn.c
  group arch
    ../../../src/arch/cortex_m/: tn_arch_cortex_m_c.c tn_arch_cortex_m.S
