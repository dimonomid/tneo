# Keil uVision project tn_stm32f4_example_basic.uvprojx, settings and files
target stm32f4_discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tn_stm32f4_example_basic
  c flags: Optim=1 uC99=1 wLevel=2
  c define: HSE_VALUE=8000000
  c include: ..\..\..\..\..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../../../../../../src/arch/cortex_m/keil5_uvision/Objects/: tneokernel_cortex_m_keil5.lib
    ../: tn_stm32f4_example_basic.c
  group ::Device
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s system_stm32f4xx.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1
