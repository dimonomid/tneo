# Keil uVision project tneokernel_cortex_m_keil5.uvprojx, settings and files
target tneokernel_cortex_m_keil5 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tneokernel_cortex_m_keil5 (library)
  c flags: Optim=4 uC99=1 wLevel=2
  c include: ..\..\..\core;..\..\..\core\internal;..\..\..;..\..\..\arch;..\..\..\arch\cortex_m
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../../../core/: tn_timer.c tn_dqueue.c tn_eventgrp.c tn_fmem.c tn_list.c tn_mutex.c tn_sem.c tn_sys.c tn_tasks.c
  group arch
    ../: tn_arch_cortex_m_c.c tn_arch_cortex_m.S
